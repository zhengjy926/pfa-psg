# Keil uVision project psg_v3.uvprojx, settings and files
target psg_v3 (6230000::V6.23::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IROM(0x08000000-0x803FFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: psg_v3 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: STM32G474xx,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: ..;..\third_party\freertos\Source\include;..\third_party\freertos\Source\portable\GCC\ARM_CM4F;..\third_party\cmsis\include;..\third_party\cmsis\device\include;..\bsp\psg_v3
  asm misc: --diag_suppress=3910
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../app/: main.c psg_app.c psg_app_tasks.c psg_ecsp.c psg_reports.c
    ../app/ecsp/: ecsp_frame.c ecsp_rx.c ecsp_session.c ecsp_tx.c
  group Run
    ../run/: pulse_engine.c run_config.c
  group Services
    ../svc/dedup/: dedup.c
    ../svc/fault/: fault.c
    ../svc/identity/: identity.c
  group Drivers
    ../drv/uart/: uart_ring.c
    ../drv/stm32g4/: stm32_timebase.c stm32_led.c stm32_uart.c stm32_comp.c stm32_iwdg.c stm32_watchdog.c stm32_flash.c
  group BSP
    ../bsp/psg_v3/: psg_board.c
  group Utils
    ../utils/: psg_log.c
  group FreeRTOS
    ../third_party/freertos/Source/: tasks.c queue.c list.c
    ../third_party/freertos/Source/portable/GCC/ARM_CM4F/: port.c
  group CMSIS
    ../third_party/cmsis/device/src/: system_stm32g4xx.c
    ../third_party/cmsis/startup/arm/: startup_stm32g474xx.s
